<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>Debug</name>
    <toolchain>
      <name>STM8</name>
    </toolchain>
    <debug>1</debug>
  </configuration>
  <configuration>
    <name>Release</name>
    <toolchain>
      <name>STM8</name>
    </toolchain>
    <debug>0</debug>
  </configuration>
  <group>
    <name>STM8S Library</name>
    <group>
      <name>inc</name>
      <file>
        <name>$PROJ_DIR$\STM8S_StdPeriph_Driver\inc\stm8s_adc1.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\STM8S_StdPeriph_Driver\inc\stm8s_clk.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\STM8S_StdPeriph_Driver\inc\stm8s_exti.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\STM8S_StdPeriph_Driver\inc\stm8s_flash.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\STM8S_StdPeriph_Driver\inc\stm8s_gpio.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\STM8S_StdPeriph_Driver\inc\stm8s_spi.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\STM8S_StdPeriph_Driver\inc\stm8s_tim2.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\STM8S_StdPeriph_Driver\inc\stm8s_tim3.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\STM8S_StdPeriph_Driver\inc\stm8s_tim4.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\STM8S_StdPeriph_Driver\inc\stm8s_uart2.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\STM8S_StdPeriph_Driver\inc\stm8s_wwdg.h</name>
      </file>
    </group>
    <group>
      <name>src</name>
      <file>
        <name>$PROJ_DIR$\STM8S_StdPeriph_Driver\src\stm8s_adc1.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\STM8S_StdPeriph_Driver\src\stm8s_clk.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\STM8S_StdPeriph_Driver\src\stm8s_exti.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\STM8S_StdPeriph_Driver\src\stm8s_flash.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\STM8S_StdPeriph_Driver\src\stm8s_gpio.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\STM8S_StdPeriph_Driver\src\stm8s_spi.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\STM8S_StdPeriph_Driver\src\stm8s_tim1.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\STM8S_StdPeriph_Driver\src\stm8s_tim2.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\STM8S_StdPeriph_Driver\src\stm8s_tim3.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\STM8S_StdPeriph_Driver\src\stm8s_tim4.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\STM8S_StdPeriph_Driver\src\stm8s_uart2.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\STM8S_StdPeriph_Driver\src\stm8s_wwdg.c</name>
      </file>
    </group>
  </group>
  <group>
    <name>User</name>
    <group>
      <name>Common</name>
      <file>
        <name>$PROJ_DIR$\..\xlightCommon-stm8s\Xlight_lib\debugDefine.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\xlightCommon-stm8s\Xlight_lib\FlashDataStorage.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\xlightCommon-stm8s\Xlight_lib\FlashDataStorage.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\xlightCommon-stm8s\Xlight_lib\MyMessage.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\xlightCommon-stm8s\Xlight_lib\publicDefine.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\xlightCommon-stm8s\Xlight_lib\rf24l01.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\xlightCommon-stm8s\Xlight_lib\rf24l01.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\xlightCommon-stm8s\Xlight_lib\timer_2.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\xlightCommon-stm8s\Xlight_lib\timer_2.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\xlightCommon-stm8s\Xlight_lib\Uart2Dev.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\xlightCommon-stm8s\Xlight_lib\Uart2Dev.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\xlightCommon-stm8s\Xlight_lib\wwdg.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\xlightCommon-stm8s\Xlight_lib\wwdg.h</name>
      </file>
    </group>
    <group>
      <name>inc</name>
      <file>
        <name>$PROJ_DIR$\Project\inc\_global.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Project\inc\ADC1Dev.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Project\inc\button.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Project\inc\infrared.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Project\inc\keySimulator.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Project\inc\ProtocolParser.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Project\inc\relay_key.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Project\inc\sen_als.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Project\inc\sen_dht.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Project\inc\sen_irkey.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Project\inc\sen_mic.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Project\inc\sen_pir.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Project\inc\sen_pm25.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Project\inc\timer_4.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Project\inc\xliNodeConfig.h</name>
      </file>
    </group>
    <group>
      <name>src</name>
      <file>
        <name>$PROJ_DIR$\Project\src\ADC1Dev.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Project\src\button.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Project\src\infrared.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Project\src\keySimulator.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Project\src\main.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Project\src\ProtocolParser.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Project\src\relay_key.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Project\src\sen_als.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Project\src\sen_dht.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Project\src\sen_irkey.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Project\src\sen_mic.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Project\src\sen_pir.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Project\src\sen_pm25.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Project\src\timer_4.c</name>
      </file>
    </group>
  </group>
</project>


